FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://un-config.cfg"

PR := "${PR}.1"

