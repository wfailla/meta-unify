FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://patch_disable_Werror.patch"
