LDSHARED += "-Wl,-shared"
